# IAR project Master_w_Sensor.ewp, settings and files
configuration Polling (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLUENRG2_DEVICE; USE_FULL_ASSERT; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\..\Library\hal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Master_w_Sensor_Polling.bin
  ILINK.IlinkOutputFile: Master_w_Sensor.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Dma (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG2_DEVICE; USE_FULL_ASSERT; BLUENRG1_SPI_DMA; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ
  OBJCOPY.OOCOutputFile: Master_w_Sensor_Dma.bin
configuration Interrupt (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG2_DEVICE; USE_FULL_ASSERT; BLUENRG1_SPI_IRQ; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ
  OBJCOPY.OOCOutputFile: Master_w_Sensor_Interrupt.bin
  group (top)
    ../../: BlueNRG1_it.c SPI_Master_w_Sensor_main.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group SDK_Eval_BlueNRG1
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Startup
    ../../../../../../Library/hal/src/: context_switch.s
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
