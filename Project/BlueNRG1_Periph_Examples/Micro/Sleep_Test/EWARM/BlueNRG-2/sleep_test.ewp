# IAR project sleep_test.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.IExtraOptions: --diag_warning Pe1665; --diag_suppress Pe1665
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\..\Library\Bluetooth_LE\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sleep_test.bin
  ILINK.IlinkOutputFile: sleep_test.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Hal
    ../../../../../../Library/hal/src/: context_switch.s osal.c sleep.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platforms_Layers
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
  group Startup
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../: BlueNRG1_it.c hw_config.c Micro_Sleep_Test_main.c
