# Keil uVision project Master_w_Sensor.uvprojx, settings and files
target Polling (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.0.0.1
  cpu: IROM(0x10040000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Master_w_Sensor +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: BLUENRG2_DEVICE USE_FULL_ASSERT HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ
  c include: ..\..\..\Master_w_Sensor;..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\hal\inc;..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  group BlueNRG1_Periph_Driver
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group SDK_Eval_BlueNRG1
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Startup
    ../../../../../../Library/hal/src/: context_switch.s
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../: BlueNRG1_it.c I2C_Master_w_Sensor_main.c
target Interrupt (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.0.0.1
  cpu: as above
  output: Master_w_Sensor +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: BLUENRG2_DEVICE USE_FULL_ASSERT BLUENRG1_I2C_IRQ HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
target Dma (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.0.0.1
  cpu: as above
  output: Master_w_Sensor +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: BLUENRG2_DEVICE USE_FULL_ASSERT BLUENRG1_I2C_DMA HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
