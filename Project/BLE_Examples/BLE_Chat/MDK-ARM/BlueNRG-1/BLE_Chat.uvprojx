# Keil uVision project BLE_Chat.uvprojx, settings and files
target Client (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Chat_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\BLE_Chat_Client.axf --output Client\Objects\BLE_Chat_Client.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\Bluetooth_LE\OTA\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  group BlueNRG1_Periph_Driver
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Platforms_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Button.c SDK_EVAL_Led.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c gatt_db.c chat.c BLE_Chat_main.c AtProcess.c Configinf.c
  group Hal
    ../../../../../Library/hal/src/: osal.c context_switch.s clock.c gp_timer.c sleep.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
  group OTA
    ../../../../../Library/Bluetooth_LE/OTA/src/: OTA_btl.c
target Server (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Chat_Server +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
